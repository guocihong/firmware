# Keil uVision project player.uvproj, settings and files
target ALARM (MCS-51)
  device: STC12C5A32S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: 控制杆攀爬报警-带可设置延时 +hex
  c flags: Optimize=7 SizeSpeed=1
  group system
    ./: main.c scheduler.c variable.c startup.a51
  group tasks
    ./tasks/comm/: comm_task.c
    ./tasks/ad/: AD_TASK.C
    ./tasks/doorkeep/: doorkeep_task.c
    ./tasks/status/: status_task.c
    ./tasks/alarm/: alarm_task.c
  group drive
    ./lib_mcu/timer/: timer_drv.c
    ./lib_mcu/uart/: uart_drv.c
    ./lib_mcu/eeprom/: eeprom_drv.c
    ./lib_mcu/adc/: adc_drv.c
